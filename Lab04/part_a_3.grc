options:
  parameters:
    author: Studente
    generate_options: qt_gui
    id: parta
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: resamp_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/alpondith/projects/PLMTSR/Lab04/am_usrp710.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '64000'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/resamp_factor
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '64000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resamp_factor
    interp: '1'
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
